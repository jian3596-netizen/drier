# Keil uVision project template.uvproj, settings and files
target TEMPLATE (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: template +hex
  c flags: Optimize=3
  c include: ..\USER;..\FUNC_HANDLER;..\GUI_APP;..\HANDWARE\UART2;..\HANDWARE\TASK;..\HANDWARE\NOR_FLASH
  link misc: REMOVEUNUSED
  group USER
    ./: STARTUP_M5.A51 main.c sys.c
  group HANDWARE
    ../HANDWARE/UART2/: uart2.c
    ../HANDWARE/TASK/: task.c
    ../HANDWARE/NOR_FLASH/: nor_flash.c
